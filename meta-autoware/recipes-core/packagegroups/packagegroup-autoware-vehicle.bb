# Generated by tools/generate-tier1-packagegroups.py, do not edit
DESCRIPTION = "Autoware vehicle: Generic vehicle interface, description and info packages"
LICENSE = "Apache-2.0"
PACKAGE_ARCH = "${MACHINE_ARCH}"

inherit packagegroup

PACKAGES = "${PN}"
ALLOW_EMPTY:${PN} = "1"

RDEPENDS:${PN} += "\
    autoware-core-vehicle \
    autoware-learning-based-vehicle-model \
    autoware-vehicle-info-utils \
    autoware-vehicle-velocity-converter \
    tier4-vehicle-launch \
"
