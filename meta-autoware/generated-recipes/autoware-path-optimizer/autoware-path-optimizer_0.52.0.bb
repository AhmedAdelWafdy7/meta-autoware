# Generated by mash -- DO NOT EDIT. See PLAN.md §5/§6 and
# meta-autoware/classes/autoware-fixups.bbclass for fixes.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "The autoware_path_optimizer package"
AUTHOR = "Takayuki Murooka <takayuki.murooka@tier4.jp>"
ROS_AUTHOR = "Takayuki Murooka <takayuki.murooka@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_universe"
ROS_BPN = "autoware_path_optimizer"

ROS_BUILD_DEPENDS = "\
    autoware-internal-debug-msgs\
    autoware-interpolation\
    autoware-motion-utils\
    autoware-osqp-interface\
    autoware-planning-msgs\
    autoware-planning-test-manager\
    autoware-utils\
    autoware-utils-geometry\
    autoware-vehicle-info-utils\
    diagnostic-updater\
    geometry-msgs\
    nav-msgs\
    rclcpp\
    rclcpp-components\
    std-msgs\
    tf2-ros\
    visualization-msgs\
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native\
    ament-cmake-export-link-flags-native\
    autoware-cmake-native\
"

ROS_EXPORT_DEPENDS = "\
    autoware-internal-debug-msgs\
    autoware-interpolation\
    autoware-motion-utils\
    autoware-osqp-interface\
    autoware-planning-msgs\
    autoware-planning-test-manager\
    autoware-utils\
    autoware-utils-geometry\
    autoware-vehicle-info-utils\
    diagnostic-updater\
    geometry-msgs\
    nav-msgs\
    rclcpp\
    rclcpp-components\
    std-msgs\
    tf2-ros\
    visualization-msgs\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    autoware-global-parameter-loader\
    autoware-internal-debug-msgs\
    autoware-interpolation\
    autoware-motion-utils\
    autoware-osqp-interface\
    autoware-planning-msgs\
    autoware-planning-test-manager\
    autoware-utils\
    autoware-utils-geometry\
    autoware-vehicle-info-utils\
    diagnostic-updater\
    geometry-msgs\
    nav-msgs\
    rclcpp\
    rclcpp-components\
    std-msgs\
    tf2-ros\
    visualization-msgs\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-ros\
    ament-index-python\
    ament-lint-auto\
    autoware-fake-test-node\
    autoware-lint-common\
    autoware-testing\
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=humble"
SRC_URI = "git://github.com/autowarefoundation/autoware_universe.git;${ROS_BRANCH};protocol=https"
SRCREV = "6e477c645efec33f7909095eea684474e97f5e3d"
S = "${WORKDIR}/git/planning/autoware_path_optimizer"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
