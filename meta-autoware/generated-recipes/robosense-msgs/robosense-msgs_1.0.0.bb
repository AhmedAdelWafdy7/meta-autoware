# Generated by mash -- DO NOT EDIT. See PLAN.md §5/§6 and
# meta-autoware/classes/autoware-fixups.bbclass for fixes.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "Robosense message types for Nebula"
AUTHOR = "David Wong <david.wong@tier4.jp>"
ROS_AUTHOR = "Mehmet Emin Basoglu <memin@leodrive.ai>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "nebula"
ROS_BPN = "robosense_msgs"

ROS_BUILD_DEPENDS = "\
    builtin-interfaces\
    std-msgs\
"

ROS_BUILDTOOL_DEPENDS = "\
    autoware-cmake-native\
    rosidl-default-generators-native\
"

ROS_EXPORT_DEPENDS = "\
    builtin-interfaces\
    std-msgs\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    rosidl-default-runtime\
    builtin-interfaces\
    std-msgs\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=main"
SRC_URI = "git://github.com/tier4/nebula.git;${ROS_BRANCH};protocol=https"
SRCREV = "9cb61cc9658172ab8907d8967258d7b3e92cd476"
S = "${WORKDIR}/git/src/nebula_robosense/robosense_msgs"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
