# Generated by mash -- DO NOT EDIT. See PLAN.md §5/§6 and
# meta-autoware/classes/autoware-fixups.bbclass for fixes.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "The rtklib_msgs package"
AUTHOR = "megken <megken@todo.todo>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "rtklib_ros_bridge"
ROS_BPN = "rtklib_msgs"

ROS_BUILD_DEPENDS = "\
    rosidl-default-generators\
    builtin-interfaces\
    std-msgs\
    geometry-msgs\
    sensor-msgs\
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native\
"

ROS_EXPORT_DEPENDS = "\
    builtin-interfaces\
    std-msgs\
    geometry-msgs\
    sensor-msgs\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    rosidl-default-runtime\
    builtin-interfaces\
    std-msgs\
    geometry-msgs\
    sensor-msgs\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto\
    ament-lint-common\
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=ros2-v0.1.0"
SRC_URI = "git://github.com/MapIV/rtklib_ros_bridge.git;${ROS_BRANCH};protocol=https"
SRCREV = "ef094407bba4f475a8032972e0c60cbb939b51b8"
S = "${WORKDIR}/git/rtklib_msgs"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
