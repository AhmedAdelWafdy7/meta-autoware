# Generated by mash -- DO NOT EDIT. Fixes go in
# meta-autoware/classes/autoware-fixups.bbclass or a .bbappend.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "The collision_detector package"
AUTHOR = "Hayate Sugahara <hayate.sugahara@tier4.jp>"
ROS_AUTHOR = "Shinnosuke Hirakawa <shinnosuke.hirakawa@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_universe"
ROS_BPN = "autoware_collision_detector"

ROS_BUILD_DEPENDS = "\
    autoware-cmake\
    autoware-adapi-v1-msgs\
    autoware-agnocast-wrapper\
    autoware-motion-utils\
    autoware-object-recognition-utils\
    autoware-perception-msgs\
    autoware-utils\
    autoware-vehicle-info-utils\
    diagnostic-msgs\
    diagnostic-updater\
    libeigen\
    pcl\
    pcl-conversions\
    rclcpp\
    rclcpp-components\
    sensor-msgs\
    std-msgs\
    tf2\
    tf2-eigen\
    tf2-geometry-msgs\
    tf2-ros\
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native\
    eigen3-cmake-module-native\
"

ROS_EXPORT_DEPENDS = "\
    autoware-adapi-v1-msgs\
    autoware-agnocast-wrapper\
    autoware-motion-utils\
    autoware-object-recognition-utils\
    autoware-perception-msgs\
    autoware-utils\
    autoware-vehicle-info-utils\
    diagnostic-msgs\
    diagnostic-updater\
    libeigen\
    pcl\
    pcl-conversions\
    rclcpp\
    rclcpp-components\
    sensor-msgs\
    std-msgs\
    tf2\
    tf2-eigen\
    tf2-geometry-msgs\
    tf2-ros\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    autoware-adapi-v1-msgs\
    autoware-agnocast-wrapper\
    autoware-motion-utils\
    autoware-object-recognition-utils\
    autoware-perception-msgs\
    autoware-utils\
    autoware-vehicle-info-utils\
    diagnostic-msgs\
    diagnostic-updater\
    libeigen\
    pcl\
    pcl-conversions\
    rclcpp\
    rclcpp-components\
    sensor-msgs\
    std-msgs\
    tf2\
    tf2-eigen\
    tf2-geometry-msgs\
    tf2-ros\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto\
    autoware-lint-common\
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=humble"
SRC_URI = "git://github.com/autowarefoundation/autoware_universe.git;${ROS_BRANCH};protocol=https"
SRCREV = "815d3f1b5c532eaccab33f0479819af8535919d2"
S = "${WORKDIR}/git/control/autoware_collision_detector"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
