# Generated by mash -- DO NOT EDIT. Fixes go in
# meta-autoware/classes/autoware-fixups.bbclass or a .bbappend.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "The autoware_component_interface_utils package"
AUTHOR = "Yutaka Kondo <yutaka.kondo@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_core"
ROS_BPN = "autoware_component_interface_utils"

ROS_BUILD_DEPENDS = "\
    autoware-adapi-v1-msgs\
    autoware-component-interface-specs\
    nlohmann-json\
    rcl\
    rclcpp\
    rclcpp-components\
    rmw\
    rosidl-runtime-cpp\
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native\
    autoware-cmake-native\
"

ROS_EXPORT_DEPENDS = "\
    autoware-adapi-v1-msgs\
    autoware-component-interface-specs\
    nlohmann-json\
    rcl\
    rclcpp\
    rclcpp-components\
    rmw\
    rosidl-runtime-cpp\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    autoware-adapi-v1-msgs\
    autoware-component-interface-specs\
    nlohmann-json\
    rcl\
    rclcpp\
    rclcpp-components\
    rmw\
    rosidl-runtime-cpp\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-ros\
    ament-lint-auto\
    autoware-lint-common\
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=humble"
SRC_URI = "git://github.com/autowarefoundation/autoware_core.git;${ROS_BRANCH};protocol=https"
SRCREV = "384bcd47e6d2fd21e5954a915153aa5303b34a53"
S = "${WORKDIR}/git/common/autoware_component_interface_utils"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
