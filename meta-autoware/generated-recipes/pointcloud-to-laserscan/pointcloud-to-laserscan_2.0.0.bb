# Generated by mash -- DO NOT EDIT. See PLAN.md §5/§6 and
# meta-autoware/classes/autoware-fixups.bbclass for fixes.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "Converts a 3D Point Cloud into a 2D laser scan. This is useful for making devices like the Kinect appear like a laser scanner for 2D-based algorithms (e.g. laser-based SLAM)."
AUTHOR = "Paul Bovbel <paul@bovbel.com>"
ROS_AUTHOR = "Paul Bovbel <paul@bovbel.com>"
HOMEPAGE = "http://ros.org/wiki/perception_pcl"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=01c2bc31767ccb3a68e12f02612b2a97"

ROS_CN = "pointcloud_to_laserscan"
ROS_BPN = "pointcloud_to_laserscan"

ROS_BUILD_DEPENDS = "\
    laser-geometry\
    pcl\
    message-filters\
    pcl-conversions\
    rclcpp\
    rclcpp-components\
    sensor-msgs\
    tf2\
    tf2-ros\
    tf2-sensor-msgs\
    visualization-msgs\
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native\
"

ROS_EXPORT_DEPENDS = "\
    laser-geometry\
    pcl\
    message-filters\
    pcl-conversions\
    rclcpp\
    rclcpp-components\
    sensor-msgs\
    tf2\
    tf2-ros\
    tf2-sensor-msgs\
    visualization-msgs\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    launch\
    launch-ros\
    laser-geometry\
    pcl\
    message-filters\
    pcl-conversions\
    rclcpp\
    rclcpp-components\
    sensor-msgs\
    tf2\
    tf2-ros\
    tf2-sensor-msgs\
    visualization-msgs\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto\
    ament-cmake-cppcheck\
    ament-cmake-cpplint\
    ament-cmake-flake8\
    ament-cmake-lint-cmake\
    ament-cmake-pep257\
    ament-cmake-uncrustify\
    ament-cmake-xmllint\
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=tier4/main"
SRC_URI = "git://github.com/tier4/pointcloud_to_laserscan.git;${ROS_BRANCH};protocol=https"
SRCREV = "d969ec699f84fad827fbadfa3001c9c657482fbe"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
