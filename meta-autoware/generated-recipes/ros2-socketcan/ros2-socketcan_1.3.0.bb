# Generated by mash -- DO NOT EDIT. See PLAN.md §5/§6 and
# meta-autoware/classes/autoware-fixups.bbclass for fixes.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "Simple wrapper around SocketCAN"
AUTHOR = "Josh Whitley <whitleysoftwareservices@gmail.com>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "ros2_socketcan"
ROS_BPN = "ros2_socketcan"

ROS_BUILD_DEPENDS = "\
    rclcpp\
    rclcpp-components\
    rclcpp-lifecycle\
    lifecycle-msgs\
    can-msgs\
    ros2-socketcan-msgs\
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native\
"

ROS_EXPORT_DEPENDS = "\
    rclcpp\
    rclcpp-components\
    rclcpp-lifecycle\
    lifecycle-msgs\
    can-msgs\
    ros2-socketcan-msgs\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    rclcpp\
    rclcpp-components\
    rclcpp-lifecycle\
    lifecycle-msgs\
    can-msgs\
    ros2-socketcan-msgs\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto\
    ament-lint-common\
    ament-cmake-gtest\
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=main"
SRC_URI = "git://github.com/autowarefoundation/ros2_socketcan;${ROS_BRANCH};protocol=https"
SRCREV = "e39a814180b03f00a5692b6951a5d4e9f0463486"
S = "${WORKDIR}/git/ros2_socketcan"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
