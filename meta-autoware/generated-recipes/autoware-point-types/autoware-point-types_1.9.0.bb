# Generated by mash -- DO NOT EDIT. See PLAN.md §5/§6 and
# meta-autoware/classes/autoware-fixups.bbclass for fixes.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "The point types definition to use point_cloud_msg_wrapper"
AUTHOR = "David Wong <david.wong@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_core"
ROS_BPN = "autoware_point_types"

ROS_BUILD_DEPENDS = "\
    ament-cmake-copyright\
    ament-cmake-cppcheck\
    ament-cmake-lint-cmake\
    ament-cmake-xmllint\
    pcl-ros\
    point-cloud-msg-wrapper\
    sensor-msgs\
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-core-native\
    ament-cmake-export-dependencies-native\
    ament-cmake-test-native\
    autoware-cmake-native\
"

ROS_EXPORT_DEPENDS = "\
    ament-cmake-copyright\
    ament-cmake-cppcheck\
    ament-cmake-lint-cmake\
    ament-cmake-xmllint\
    pcl-ros\
    point-cloud-msg-wrapper\
    sensor-msgs\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native\
    ament-cmake-test-native\
"

ROS_EXEC_DEPENDS = "\
    ament-cmake-copyright\
    ament-cmake-cppcheck\
    ament-cmake-lint-cmake\
    ament-cmake-xmllint\
    pcl-ros\
    point-cloud-msg-wrapper\
    sensor-msgs\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-ros\
    ament-lint-auto\
    autoware-lint-common\
    point-cloud-msg-wrapper\
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=humble"
SRC_URI = "git://github.com/autowarefoundation/autoware_core.git;${ROS_BRANCH};protocol=https"
SRCREV = "f25f83c632c1984ec276c894c41857d4abc0dad8"
S = "${WORKDIR}/git/common/autoware_point_types"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
