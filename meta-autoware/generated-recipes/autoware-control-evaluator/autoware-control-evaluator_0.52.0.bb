# Generated by mash -- DO NOT EDIT. See PLAN.md §5/§6 and
# meta-autoware/classes/autoware-fixups.bbclass for fixes.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "ROS 2 node for evaluating control"
AUTHOR = "Daniel SANCHEZ <daniel.sanchez@tier4.jp>"
ROS_AUTHOR = "Daniel SANCHEZ <daniel.sanchez@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_universe"
ROS_BPN = "autoware_control_evaluator"

ROS_BUILD_DEPENDS = "\
    autoware-deprecated-boundary-departure-checker\
    autoware-internal-planning-msgs\
    autoware-lanelet2-utils\
    autoware-motion-utils\
    autoware-object-recognition-utils\
    autoware-perception-msgs\
    autoware-planning-factor-interface\
    autoware-planning-msgs\
    autoware-route-handler\
    autoware-test-utils\
    autoware-utils\
    autoware-vehicle-info-utils\
    autoware-vehicle-msgs\
    nav-msgs\
    nlohmann-json\
    pluginlib\
    rclcpp\
    rclcpp-components\
    tf2\
    tf2-ros\
    tier4-metric-msgs\
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native\
    autoware-cmake-native\
"

ROS_EXPORT_DEPENDS = "\
    autoware-deprecated-boundary-departure-checker\
    autoware-internal-planning-msgs\
    autoware-lanelet2-utils\
    autoware-motion-utils\
    autoware-object-recognition-utils\
    autoware-perception-msgs\
    autoware-planning-factor-interface\
    autoware-planning-msgs\
    autoware-route-handler\
    autoware-test-utils\
    autoware-utils\
    autoware-vehicle-info-utils\
    autoware-vehicle-msgs\
    nav-msgs\
    nlohmann-json\
    pluginlib\
    rclcpp\
    rclcpp-components\
    tf2\
    tf2-ros\
    tier4-metric-msgs\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    autoware-deprecated-boundary-departure-checker\
    autoware-internal-planning-msgs\
    autoware-lanelet2-utils\
    autoware-motion-utils\
    autoware-object-recognition-utils\
    autoware-perception-msgs\
    autoware-planning-factor-interface\
    autoware-planning-msgs\
    autoware-route-handler\
    autoware-test-utils\
    autoware-utils\
    autoware-vehicle-info-utils\
    autoware-vehicle-msgs\
    nav-msgs\
    nlohmann-json\
    pluginlib\
    rclcpp\
    rclcpp-components\
    tf2\
    tf2-ros\
    tier4-metric-msgs\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-ros\
    ament-lint-auto\
    autoware-lint-common\
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=humble"
SRC_URI = "git://github.com/autowarefoundation/autoware_universe.git;${ROS_BRANCH};protocol=https"
SRCREV = "6e477c645efec33f7909095eea684474e97f5e3d"
S = "${WORKDIR}/git/evaluator/autoware_control_evaluator"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
