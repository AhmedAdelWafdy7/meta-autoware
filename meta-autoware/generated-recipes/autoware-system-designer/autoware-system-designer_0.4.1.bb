# Generated by mash -- DO NOT EDIT. See PLAN.md §5/§6 and
# meta-autoware/classes/autoware-fixups.bbclass for fixes.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "The autoware_system_designer package"
AUTHOR = "Taekjin Lee <taekjin.lee@tier4.jp>"
ROS_AUTHOR = "Taekjin Lee <taekjin.lee@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_system_designer"
ROS_BPN = "autoware_system_designer"

ROS_BUILD_DEPENDS = "\
    python3-jinja2\
    python3-pyyaml\
    python3-jsonschema\
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native\
    ament-cmake-python-native\
    autoware-cmake-native\
"

ROS_EXPORT_DEPENDS = "\
    python3-jinja2\
    python3-pyyaml\
    python3-jsonschema\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ament-index-python\
    python3-jinja2\
    python3-pyyaml\
    python3-jsonschema\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=main"
SRC_URI = "git://github.com/autowarefoundation/autoware_system_designer.git;${ROS_BRANCH};protocol=https"
SRCREV = "0bb96f29d8e27ee88658b506fa56967054b19f64"
S = "${WORKDIR}/git/autoware_system_designer"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
