# Generated by mash -- DO NOT EDIT. See PLAN.md §5/§6 and
# meta-autoware/classes/autoware-fixups.bbclass for fixes.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "Nebula HW Interfaces Hesai"
AUTHOR = "David Wong <david.wong@tier4.jp>"
ROS_AUTHOR = "TIER IV"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "Apache 2"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=fc216ef9336537897fbeafa564601763"

ROS_CN = "nebula"
ROS_BPN = "nebula_hesai_hw_interfaces"

ROS_BUILD_DEPENDS = "\
    boost\
    nebula-core-common\
    nebula-core-hw-interfaces\
    nebula-hesai-common\
"

ROS_BUILDTOOL_DEPENDS = "\
    autoware-cmake-native\
"

ROS_EXPORT_DEPENDS = "\
    boost\
    nebula-core-common\
    nebula-core-hw-interfaces\
    nebula-hesai-common\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    boost\
    nebula-core-common\
    nebula-core-hw-interfaces\
    nebula-hesai-common\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=main"
SRC_URI = "git://github.com/tier4/nebula.git;${ROS_BRANCH};protocol=https"
SRCREV = "9cb61cc9658172ab8907d8967258d7b3e92cd476"
S = "${WORKDIR}/git/src/nebula_hesai/nebula_hesai_hw_interfaces"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
