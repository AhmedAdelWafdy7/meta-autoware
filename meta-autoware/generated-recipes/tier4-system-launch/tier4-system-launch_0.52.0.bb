# Generated by mash -- DO NOT EDIT. See PLAN.md §5/§6 and
# meta-autoware/classes/autoware-fixups.bbclass for fixes.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "The tier4_system_launch package"
AUTHOR = "Fumihito Ito <fumihito.ito@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_launch"
ROS_BPN = "tier4_system_launch"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native\
    autoware-cmake-native\
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    autoware-command-mode-decider\
    autoware-command-mode-switcher\
    autoware-component-interface-tools\
    autoware-component-state-monitor\
    autoware-diagnostic-graph-aggregator\
    autoware-dummy-diag-publisher\
    autoware-duplicated-node-checker\
    autoware-hazard-status-converter\
    autoware-mrm-comfortable-stop-operator\
    autoware-mrm-emergency-stop-operator\
    autoware-mrm-handler\
    autoware-pipeline-latency-monitor\
    autoware-processing-time-checker\
    autoware-system-monitor\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto\
    autoware-lint-common\
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=humble"
SRC_URI = "git://github.com/autowarefoundation/autoware_launch.git;${ROS_BRANCH};protocol=https"
SRCREV = "f942598d44b5769353167c76b784323d5c14c8c7"
S = "${WORKDIR}/git/tier4_universe_launch/tier4_system_launch"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
