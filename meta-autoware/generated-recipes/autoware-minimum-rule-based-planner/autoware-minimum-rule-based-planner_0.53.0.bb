# Generated by mash -- DO NOT EDIT. Fixes go in
# meta-autoware/classes/autoware-fixups.bbclass or a .bbappend.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "The minimum_rule_based_planner package"
AUTHOR = "Takumi Odashima <takumi.odashima@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_universe"
ROS_BPN = "autoware_minimum_rule_based_planner"

ROS_BUILD_DEPENDS = "\
    generate-parameter-library\
    autoware-agnocast-wrapper\
    autoware-internal-debug-msgs\
    autoware-internal-planning-msgs\
    autoware-lanelet2-extension\
    autoware-map-msgs\
    autoware-motion-utils\
    autoware-obstacle-proximity-checker\
    autoware-perception-msgs\
    autoware-planning-factor-interface\
    autoware-planning-msgs\
    autoware-planning-test-manager\
    autoware-qp-interface\
    autoware-trajectory\
    autoware-trajectory-modifier\
    autoware-utils\
    autoware-utils-debug\
    autoware-utils-uuid\
    autoware-vehicle-info-utils\
    autoware-vehicle-msgs\
    autoware-velocity-smoother\
    geometry-msgs\
    boost\
    opencv\
    magic-enum\
    nav-msgs\
    pluginlib\
    rclcpp\
    rclcpp-components\
    sensor-msgs\
    tf2\
    tf2-eigen\
    tf2-geometry-msgs\
    tf2-ros\
    tier4-planning-msgs\
    visualization-msgs\
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native\
    autoware-cmake-native\
"

ROS_EXPORT_DEPENDS = "\
    autoware-agnocast-wrapper\
    autoware-internal-debug-msgs\
    autoware-internal-planning-msgs\
    autoware-lanelet2-extension\
    autoware-map-msgs\
    autoware-motion-utils\
    autoware-obstacle-proximity-checker\
    autoware-perception-msgs\
    autoware-planning-factor-interface\
    autoware-planning-msgs\
    autoware-planning-test-manager\
    autoware-qp-interface\
    autoware-trajectory\
    autoware-trajectory-modifier\
    autoware-utils\
    autoware-utils-debug\
    autoware-utils-uuid\
    autoware-vehicle-info-utils\
    autoware-vehicle-msgs\
    autoware-velocity-smoother\
    geometry-msgs\
    boost\
    opencv\
    magic-enum\
    nav-msgs\
    pluginlib\
    rclcpp\
    rclcpp-components\
    sensor-msgs\
    tf2\
    tf2-eigen\
    tf2-geometry-msgs\
    tf2-ros\
    tier4-planning-msgs\
    visualization-msgs\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    autoware-core-planning\
    autoware-agnocast-wrapper\
    autoware-internal-debug-msgs\
    autoware-internal-planning-msgs\
    autoware-lanelet2-extension\
    autoware-map-msgs\
    autoware-motion-utils\
    autoware-obstacle-proximity-checker\
    autoware-perception-msgs\
    autoware-planning-factor-interface\
    autoware-planning-msgs\
    autoware-planning-test-manager\
    autoware-qp-interface\
    autoware-trajectory\
    autoware-trajectory-modifier\
    autoware-utils\
    autoware-utils-debug\
    autoware-utils-uuid\
    autoware-vehicle-info-utils\
    autoware-vehicle-msgs\
    autoware-velocity-smoother\
    geometry-msgs\
    boost\
    opencv\
    magic-enum\
    nav-msgs\
    pluginlib\
    rclcpp\
    rclcpp-components\
    sensor-msgs\
    tf2\
    tf2-eigen\
    tf2-geometry-msgs\
    tf2-ros\
    tier4-planning-msgs\
    visualization-msgs\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-ros\
    ament-lint-auto\
    autoware-lint-common\
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=humble"
SRC_URI = "git://github.com/autowarefoundation/autoware_universe.git;${ROS_BRANCH};protocol=https"
SRCREV = "815d3f1b5c532eaccab33f0479819af8535919d2"
S = "${WORKDIR}/git/planning/autoware_minimum_rule_based_planner"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
