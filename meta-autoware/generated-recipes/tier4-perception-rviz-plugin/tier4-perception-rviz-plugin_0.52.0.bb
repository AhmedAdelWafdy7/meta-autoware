# Generated by mash -- DO NOT EDIT. See PLAN.md §5/§6 and
# meta-autoware/classes/autoware-fixups.bbclass for fixes.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "Contains plugins to visualize object detection outputs"
AUTHOR = "Yoshi Ri <yoshi.ri@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=3dce4ba60d7e51ec64f3c3dc18672dd3"

ROS_CN = "autoware_universe"
ROS_BPN = "tier4_perception_rviz_plugin"

ROS_BUILD_DEPENDS = "\
    boost\
    qtbase\
    pcl-conversions\
    rviz-common\
    rviz-default-plugins\
    tier4-perception-msgs\
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native\
    autoware-cmake-native\
"

ROS_EXPORT_DEPENDS = "\
    pcl-conversions\
    rviz-common\
    rviz-default-plugins\
    tier4-perception-msgs\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    qtbase\
    rviz2\
    pcl-conversions\
    rviz-common\
    rviz-default-plugins\
    tier4-perception-msgs\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto\
    autoware-lint-common\
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=humble"
SRC_URI = "git://github.com/autowarefoundation/autoware_universe.git;${ROS_BRANCH};protocol=https"
SRCREV = "6e477c645efec33f7909095eea684474e97f5e3d"
S = "${WORKDIR}/git/visualization/tier4_perception_rviz_plugin"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
