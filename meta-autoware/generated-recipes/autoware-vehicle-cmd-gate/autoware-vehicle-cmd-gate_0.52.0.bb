# Generated by mash -- DO NOT EDIT. See PLAN.md §5/§6 and
# meta-autoware/classes/autoware-fixups.bbclass for fixes.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "The vehicle_cmd_gate package"
AUTHOR = "Yukinari Hisaki <yukinari.hisaki.2@tier4.jp>"
ROS_AUTHOR = "Hiroki OTA <hiroki.ota@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_universe"
ROS_BPN = "autoware_vehicle_cmd_gate"

ROS_BUILD_DEPENDS = "\
    rosidl-default-generators\
    autoware-adapi-v1-msgs\
    autoware-agnocast-wrapper\
    autoware-component-interface-specs-universe\
    autoware-component-interface-utils\
    autoware-control-msgs\
    autoware-internal-debug-msgs\
    autoware-motion-utils\
    autoware-utils\
    autoware-vehicle-info-utils\
    autoware-vehicle-msgs\
    diagnostic-updater\
    geometry-msgs\
    rclcpp\
    rclcpp-components\
    std-srvs\
    tier4-api-utils\
    tier4-control-msgs\
    tier4-external-api-msgs\
    tier4-system-msgs\
    tier4-vehicle-msgs\
    visualization-msgs\
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native\
    autoware-cmake-native\
"

ROS_EXPORT_DEPENDS = "\
    autoware-adapi-v1-msgs\
    autoware-agnocast-wrapper\
    autoware-component-interface-specs-universe\
    autoware-component-interface-utils\
    autoware-control-msgs\
    autoware-internal-debug-msgs\
    autoware-motion-utils\
    autoware-utils\
    autoware-vehicle-info-utils\
    autoware-vehicle-msgs\
    diagnostic-updater\
    geometry-msgs\
    rclcpp\
    rclcpp-components\
    std-srvs\
    tier4-api-utils\
    tier4-control-msgs\
    tier4-external-api-msgs\
    tier4-system-msgs\
    tier4-vehicle-msgs\
    visualization-msgs\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    rosidl-default-runtime\
    autoware-adapi-v1-msgs\
    autoware-agnocast-wrapper\
    autoware-component-interface-specs-universe\
    autoware-component-interface-utils\
    autoware-control-msgs\
    autoware-internal-debug-msgs\
    autoware-motion-utils\
    autoware-utils\
    autoware-vehicle-info-utils\
    autoware-vehicle-msgs\
    diagnostic-updater\
    geometry-msgs\
    rclcpp\
    rclcpp-components\
    std-srvs\
    tier4-api-utils\
    tier4-control-msgs\
    tier4-external-api-msgs\
    tier4-system-msgs\
    tier4-vehicle-msgs\
    visualization-msgs\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-ros\
    ament-index-cpp\
    ament-lint-auto\
    autoware-lint-common\
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=humble"
SRC_URI = "git://github.com/autowarefoundation/autoware_universe.git;${ROS_BRANCH};protocol=https"
SRCREV = "6e477c645efec33f7909095eea684474e97f5e3d"
S = "${WORKDIR}/git/control/autoware_vehicle_cmd_gate"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
