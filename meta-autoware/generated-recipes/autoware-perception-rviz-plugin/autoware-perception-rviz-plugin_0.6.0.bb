# Generated by mash -- DO NOT EDIT. See PLAN.md §5/§6 and
# meta-autoware/classes/autoware-fixups.bbclass for fixes.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "Contains plugins to visualize object detection outputs"
AUTHOR = "Apex.AI, Inc. <opensource@apex.ai>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "Apache-2.0 & CC BY-SA 4.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=3dce4ba60d7e51ec64f3c3dc18672dd3"

ROS_CN = "autoware_rviz_plugins"
ROS_BPN = "autoware_perception_rviz_plugin"

ROS_BUILD_DEPENDS = "\
    boost\
    qtbase\
    autoware-lanelet2-extension\
    autoware-map-msgs\
    autoware-perception-msgs\
    rviz-common\
    rviz-default-plugins\
    tf2-geometry-msgs\
    tf2-ros\
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native\
    autoware-cmake-native\
"

ROS_EXPORT_DEPENDS = "\
    autoware-lanelet2-extension\
    autoware-map-msgs\
    autoware-perception-msgs\
    rviz-common\
    rviz-default-plugins\
    tf2-geometry-msgs\
    tf2-ros\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    qtbase\
    rviz2\
    autoware-lanelet2-extension\
    autoware-map-msgs\
    autoware-perception-msgs\
    rviz-common\
    rviz-default-plugins\
    tf2-geometry-msgs\
    tf2-ros\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto\
    autoware-lint-common\
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=main"
SRC_URI = "git://github.com/autowarefoundation/autoware_rviz_plugins.git;${ROS_BRANCH};protocol=https"
SRCREV = "b3d59795932ee08cad52de5f1981cb8ef9d6d37c"
S = "${WORKDIR}/git/autoware_perception_rviz_plugin"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
