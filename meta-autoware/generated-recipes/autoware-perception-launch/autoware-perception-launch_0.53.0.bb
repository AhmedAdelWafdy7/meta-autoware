# Generated by mash -- DO NOT EDIT. Fixes go in
# meta-autoware/classes/autoware-fixups.bbclass or a .bbappend.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "The autoware_perception_launch package"
AUTHOR = "Yukihiro Saito <yukihiro.saito@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_launch"
ROS_BPN = "autoware_perception_launch"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native\
    autoware-cmake-native\
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    autoware-agnocast-wrapper\
    autoware-bevfusion\
    autoware-bytetrack\
    autoware-compare-map-segmentation\
    autoware-crosswalk-traffic-light-estimator\
    autoware-cuda-pointcloud-preprocessor\
    autoware-detected-object-feature-remover\
    autoware-detected-object-validation\
    autoware-detection-by-tracker\
    autoware-elevation-map-loader\
    autoware-euclidean-cluster\
    autoware-ground-segmentation\
    autoware-ground-segmentation-cuda\
    autoware-image-object-locator\
    autoware-image-projection-based-fusion\
    autoware-image-transport-decompressor\
    autoware-lidar-apollo-instance-segmentation\
    autoware-lidar-centerpoint\
    autoware-lidar-transfusion\
    autoware-map-based-prediction\
    autoware-multi-object-tracker\
    autoware-object-merger\
    autoware-object-sorter\
    autoware-occupancy-grid-map-outlier-filter\
    autoware-perception-config\
    autoware-pointcloud-preprocessor\
    autoware-probabilistic-occupancy-grid-map\
    autoware-ptv3\
    autoware-raindrop-cluster-filter\
    autoware-shape-estimation\
    autoware-simpl-prediction\
    autoware-simple-object-merger\
    autoware-tensorrt-bevdet\
    autoware-tensorrt-yolox\
    autoware-tracking-object-merger\
    autoware-traffic-light-arbiter\
    autoware-traffic-light-category-merger\
    autoware-traffic-light-classifier\
    autoware-traffic-light-fine-detector\
    autoware-traffic-light-map-based-detector\
    autoware-traffic-light-multi-camera-fusion\
    autoware-traffic-light-occlusion-predictor\
    autoware-traffic-light-selector\
    autoware-traffic-light-visualization\
    rclcpp-components\
    topic-tools\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto\
    autoware-lint-common\
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=humble"
SRC_URI = "git://github.com/autowarefoundation/autoware_launch.git;${ROS_BRANCH};protocol=https"
SRCREV = "45bd52eb298a9700c51eef556734c6cb0e4af364"
S = "${WORKDIR}/git/autoware_universe_launch/autoware_perception_launch"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
