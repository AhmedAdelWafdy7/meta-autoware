# Generated by mash -- DO NOT EDIT. See PLAN.md §5/§6 and
# meta-autoware/classes/autoware-fixups.bbclass for fixes.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "The can_velocity_converter package"
AUTHOR = "Osamu Sekino <osamu.sekino@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "eagleye"
ROS_BPN = "eagleye_can_velocity_converter"

ROS_BUILD_DEPENDS = "\
    can-msgs\
    geometry-msgs\
    rclcpp\
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native\
"

ROS_EXPORT_DEPENDS = "\
    can-msgs\
    geometry-msgs\
    rclcpp\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    can-msgs\
    geometry-msgs\
    rclcpp\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto\
    ament-lint-common\
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=autoware-main"
SRC_URI = "git://github.com/MapIV/eagleye.git;${ROS_BRANCH};protocol=https"
SRCREV = "575136ebba99892946d36d8398f228aee2136af0"
S = "${WORKDIR}/git/eagleye_util/can_velocity_converter"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
