# Generated by mash -- DO NOT EDIT. See PLAN.md §5/§6 and
# meta-autoware/classes/autoware-fixups.bbclass for fixes.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "Metapackage for Agnocast: true zero-copy IPC middleware for ROS 2."
AUTHOR = "Takahiro Ishikawa-Aso <sykwer@gmail.com>"
ROS_AUTHOR = "Takahiro Ishikawa-Aso <sykwer@gmail.com>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "agnocast"
ROS_BPN = "agnocast"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native\
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    agnocastlib\
    agnocast-cie-config-msgs\
    agnocast-cie-thread-configurator\
    agnocast-components\
    agnocast-ioctl-wrapper\
    agnocast-sample-application\
    agnocast-sample-interfaces\
    ros2agnocast\
    ros2agnocast-discovery-msgs\
    ros2agnocast-discovery-agent\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=main"
SRC_URI = "git://github.com/autowarefoundation/agnocast.git;${ROS_BRANCH};protocol=https"
SRCREV = "5164c224158b831269f7d6df89f864c037548a50"
S = "${WORKDIR}/git/src/agnocast"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
