# Generated by mash -- DO NOT EDIT. See PLAN.md §5/§6 and
# meta-autoware/classes/autoware-fixups.bbclass for fixes.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "The autoware_lanelet2_extension package contains libraries to handle Lanelet2 format data."
AUTHOR = "mitsudome-r <ryohsuke.mitsudome@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_lanelet2_extension"
ROS_BPN = "autoware_lanelet2_extension"

ROS_BUILD_DEPENDS = "\
    autoware-map-msgs\
    autoware-planning-msgs\
    geographiclib\
    geometry-msgs\
    lanelet2-core\
    lanelet2-io\
    lanelet2-maps\
    lanelet2-projection\
    lanelet2-routing\
    lanelet2-traffic-rules\
    lanelet2-validation\
    pugixml\
    range-v3\
    rclcpp\
    tf2\
    tf2-geometry-msgs\
    visualization-msgs\
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native\
    autoware-cmake-native\
"

ROS_EXPORT_DEPENDS = "\
    autoware-map-msgs\
    autoware-planning-msgs\
    geographiclib\
    geometry-msgs\
    lanelet2-core\
    lanelet2-io\
    lanelet2-maps\
    lanelet2-projection\
    lanelet2-routing\
    lanelet2-traffic-rules\
    lanelet2-validation\
    pugixml\
    range-v3\
    rclcpp\
    tf2\
    tf2-geometry-msgs\
    visualization-msgs\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    autoware-map-msgs\
    autoware-planning-msgs\
    geographiclib\
    geometry-msgs\
    lanelet2-core\
    lanelet2-io\
    lanelet2-maps\
    lanelet2-projection\
    lanelet2-routing\
    lanelet2-traffic-rules\
    lanelet2-validation\
    pugixml\
    range-v3\
    rclcpp\
    tf2\
    tf2-geometry-msgs\
    visualization-msgs\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-ros\
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=main"
SRC_URI = "git://github.com/autowarefoundation/autoware_lanelet2_extension.git;${ROS_BRANCH};protocol=https"
SRCREV = "4a3420d8cc19906e7739618f8a1686400f79b4ac"
S = "${WORKDIR}/git/autoware_lanelet2_extension"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
