# Generated by mash -- DO NOT EDIT. See PLAN.md §5/§6 and
# meta-autoware/classes/autoware-fixups.bbclass for fixes.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "ROS Foxglove Bridge"
AUTHOR = "Hans-Joachim Krauch <achim@foxglove.dev>"
ROS_AUTHOR = "Foxglove <ros-tooling+foxglove_bridge@foxglove.dev>"
HOMEPAGE = "https://github.com/foxglove/ros-foxglove-bridge"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=6;endline=6;md5=92566b45c3390e5178465bcaade208b7"

ROS_CN = "foxglove_bridge"
ROS_BPN = "foxglove_bridge"

ROS_BUILD_DEPENDS = "\
    asio\
    openssl\
    websocketpp\
    nlohmann-json\
    ros-environment\
    zlib\
    ament-index-cpp\
    rclcpp\
    rclcpp-components\
    rosx-introspection\
    resource-retriever\
    rosgraph-msgs\
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native\
"

ROS_EXPORT_DEPENDS = "\
    ament-index-cpp\
    rclcpp\
    rclcpp-components\
    rosx-introspection\
    resource-retriever\
    rosgraph-msgs\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    openssl\
    zlib\
    ament-index-cpp\
    rclcpp\
    rclcpp-components\
    rosx-introspection\
    resource-retriever\
    rosgraph-msgs\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest\
    ament-lint-auto\
    std-msgs\
    std-srvs\
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=main"
SRC_URI = "git://github.com/foxglove/ros-foxglove-bridge.git;${ROS_BRANCH};protocol=https"
SRCREV = "41f96cc6053632a472d9a821989952771b1117f2"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
