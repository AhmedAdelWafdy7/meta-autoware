# Generated by mash -- DO NOT EDIT. See PLAN.md §5/§6 and
# meta-autoware/classes/autoware-fixups.bbclass for fixes.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "The autoware_dummy_perception_publisher package"
AUTHOR = "Yukihiro Saito <yukihiro.saito@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_simple_planning_simulator"
ROS_BPN = "autoware_dummy_perception_publisher"

ROS_BUILD_DEPENDS = "\
    rosidl-default-generators\
    autoware-perception-msgs\
    autoware-point-types\
    autoware-simulation-msgs\
    autoware-trajectory\
    autoware-utils-geometry\
    autoware-utils-rclcpp\
    autoware-utils-uuid\
    pcl\
    pcl-conversions\
    rclcpp\
    sensor-msgs\
    std-msgs\
    tf2\
    tf2-geometry-msgs\
    tf2-ros\
    unique-identifier-msgs\
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native\
    autoware-cmake-native\
"

ROS_EXPORT_DEPENDS = "\
    autoware-perception-msgs\
    autoware-point-types\
    autoware-simulation-msgs\
    autoware-trajectory\
    autoware-utils-geometry\
    autoware-utils-rclcpp\
    autoware-utils-uuid\
    pcl\
    pcl-conversions\
    rclcpp\
    sensor-msgs\
    std-msgs\
    tf2\
    tf2-geometry-msgs\
    tf2-ros\
    unique-identifier-msgs\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    rosidl-default-runtime\
    autoware-perception-msgs\
    autoware-point-types\
    autoware-simulation-msgs\
    autoware-trajectory\
    autoware-utils-geometry\
    autoware-utils-rclcpp\
    autoware-utils-uuid\
    pcl\
    pcl-conversions\
    rclcpp\
    sensor-msgs\
    std-msgs\
    tf2\
    tf2-geometry-msgs\
    tf2-ros\
    unique-identifier-msgs\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-ros\
    ament-lint-auto\
    autoware-lint-common\
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=main"
SRC_URI = "git://github.com/autowarefoundation/autoware_simple_planning_simulator.git;${ROS_BRANCH};protocol=https"
SRCREV = "82d2c93a28a25f8802e8f5a21b4ec850beea9080"
S = "${WORKDIR}/git/autoware_dummy_perception_publisher"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
