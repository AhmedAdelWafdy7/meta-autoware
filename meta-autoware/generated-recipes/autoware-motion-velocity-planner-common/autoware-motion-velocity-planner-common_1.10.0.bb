# Generated by mash -- DO NOT EDIT. Fixes go in
# meta-autoware/classes/autoware-fixups.bbclass or a .bbappend.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "Common functions and interfaces for motion_velocity_planner modules"
AUTHOR = "Maxime Clement <maxime.clement@tier4.jp>"
ROS_AUTHOR = "Maxime Clement <maxime.clement@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_core"
ROS_BPN = "autoware_motion_velocity_planner_common"

ROS_BUILD_DEPENDS = "\
    autoware-behavior-velocity-planner-common\
    autoware-internal-debug-msgs\
    autoware-internal-planning-msgs\
    autoware-lanelet2-extension\
    autoware-map-msgs\
    autoware-motion-utils\
    autoware-object-recognition-utils\
    autoware-perception-msgs\
    autoware-planning-factor-interface\
    autoware-planning-msgs\
    autoware-route-handler\
    autoware-utils-debug\
    autoware-utils-geometry\
    autoware-utils-math\
    autoware-utils-rclcpp\
    autoware-utils-visualization\
    autoware-vehicle-info-utils\
    autoware-velocity-smoother\
    builtin-interfaces\
    libeigen\
    geometry-msgs\
    lanelet2-core\
    boost\
    pcl\
    nav-msgs\
    pcl-conversions\
    rclcpp\
    sensor-msgs\
    std-msgs\
    tf2\
    tf2-ros\
    visualization-msgs\
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native\
    autoware-cmake-native\
    eigen3-cmake-module-native\
"

ROS_EXPORT_DEPENDS = "\
    autoware-behavior-velocity-planner-common\
    autoware-internal-debug-msgs\
    autoware-internal-planning-msgs\
    autoware-lanelet2-extension\
    autoware-map-msgs\
    autoware-motion-utils\
    autoware-object-recognition-utils\
    autoware-perception-msgs\
    autoware-planning-factor-interface\
    autoware-planning-msgs\
    autoware-route-handler\
    autoware-utils-debug\
    autoware-utils-geometry\
    autoware-utils-math\
    autoware-utils-rclcpp\
    autoware-utils-visualization\
    autoware-vehicle-info-utils\
    autoware-velocity-smoother\
    builtin-interfaces\
    libeigen\
    geometry-msgs\
    lanelet2-core\
    boost\
    pcl\
    nav-msgs\
    pcl-conversions\
    rclcpp\
    sensor-msgs\
    std-msgs\
    tf2\
    tf2-ros\
    visualization-msgs\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    autoware-behavior-velocity-planner-common\
    autoware-internal-debug-msgs\
    autoware-internal-planning-msgs\
    autoware-lanelet2-extension\
    autoware-map-msgs\
    autoware-motion-utils\
    autoware-object-recognition-utils\
    autoware-perception-msgs\
    autoware-planning-factor-interface\
    autoware-planning-msgs\
    autoware-route-handler\
    autoware-utils-debug\
    autoware-utils-geometry\
    autoware-utils-math\
    autoware-utils-rclcpp\
    autoware-utils-visualization\
    autoware-vehicle-info-utils\
    autoware-velocity-smoother\
    builtin-interfaces\
    libeigen\
    geometry-msgs\
    lanelet2-core\
    boost\
    pcl\
    nav-msgs\
    pcl-conversions\
    rclcpp\
    sensor-msgs\
    std-msgs\
    tf2\
    tf2-ros\
    visualization-msgs\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-ros\
    ament-lint-auto\
    autoware-lint-common\
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=humble"
SRC_URI = "git://github.com/autowarefoundation/autoware_core.git;${ROS_BRANCH};protocol=https"
SRCREV = "384bcd47e6d2fd21e5954a915153aa5303b34a53"
S = "${WORKDIR}/git/planning/motion_velocity_planner/autoware_motion_velocity_planner_common"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
