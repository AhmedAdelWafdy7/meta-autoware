# Generated by mash -- DO NOT EDIT. Fixes go in
# meta-autoware/classes/autoware-fixups.bbclass or a .bbappend.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "The autoware_trajectory_modifier package for combined trajectory modification and optimization"
AUTHOR = "Maxime CLEMENT <maxime.clement@tier4.jp>"
ROS_AUTHOR = "Maxime CLEMENT <maxime.clement@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_universe"
ROS_BPN = "autoware_trajectory_modifier"

ROS_BUILD_DEPENDS = "\
    autoware-agnocast-wrapper\
    autoware-internal-debug-msgs\
    autoware-internal-planning-msgs\
    autoware-motion-utils\
    autoware-object-recognition-utils\
    autoware-obstacle-proximity-checker\
    autoware-osqp-interface\
    autoware-path-optimizer\
    autoware-path-smoother\
    autoware-planning-factor-interface\
    autoware-planning-msgs\
    autoware-point-types\
    autoware-qp-interface\
    autoware-signal-processing\
    autoware-traffic-light-compliance-checker\
    autoware-trajectory\
    autoware-utils\
    autoware-utils-debug\
    autoware-utils-math\
    autoware-utils-rclcpp\
    autoware-vehicle-info-utils\
    generate-parameter-library\
    geometry-msgs\
    nav-msgs\
    pluginlib\
    range-v3\
    rclcpp\
    rclcpp-components\
    rclpy\
    std-msgs\
    tf2\
    tf2-eigen\
    tf2-geometry-msgs\
    tf2-ros\
    tl-expected\
    visualization-msgs\
"

ROS_BUILDTOOL_DEPENDS = "\
    autoware-cmake-native\
"

ROS_EXPORT_DEPENDS = "\
    autoware-agnocast-wrapper\
    autoware-internal-debug-msgs\
    autoware-internal-planning-msgs\
    autoware-motion-utils\
    autoware-object-recognition-utils\
    autoware-obstacle-proximity-checker\
    autoware-osqp-interface\
    autoware-path-optimizer\
    autoware-path-smoother\
    autoware-planning-factor-interface\
    autoware-planning-msgs\
    autoware-point-types\
    autoware-qp-interface\
    autoware-signal-processing\
    autoware-traffic-light-compliance-checker\
    autoware-trajectory\
    autoware-utils\
    autoware-utils-debug\
    autoware-utils-math\
    autoware-utils-rclcpp\
    autoware-vehicle-info-utils\
    generate-parameter-library\
    geometry-msgs\
    nav-msgs\
    pluginlib\
    range-v3\
    rclcpp\
    rclcpp-components\
    rclpy\
    std-msgs\
    tf2\
    tf2-eigen\
    tf2-geometry-msgs\
    tf2-ros\
    tl-expected\
    visualization-msgs\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    autoware-core-planning\
    python3-matplotlib\
    autoware-agnocast-wrapper\
    autoware-internal-debug-msgs\
    autoware-internal-planning-msgs\
    autoware-motion-utils\
    autoware-object-recognition-utils\
    autoware-obstacle-proximity-checker\
    autoware-osqp-interface\
    autoware-path-optimizer\
    autoware-path-smoother\
    autoware-planning-factor-interface\
    autoware-planning-msgs\
    autoware-point-types\
    autoware-qp-interface\
    autoware-signal-processing\
    autoware-traffic-light-compliance-checker\
    autoware-trajectory\
    autoware-utils\
    autoware-utils-debug\
    autoware-utils-math\
    autoware-utils-rclcpp\
    autoware-vehicle-info-utils\
    generate-parameter-library\
    geometry-msgs\
    nav-msgs\
    pluginlib\
    range-v3\
    rclcpp\
    rclcpp-components\
    rclpy\
    std-msgs\
    tf2\
    tf2-eigen\
    tf2-geometry-msgs\
    tf2-ros\
    tl-expected\
    visualization-msgs\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-ros\
    ament-lint-auto\
    autoware-lint-common\
    autoware-test-utils\
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=humble"
SRC_URI = "git://github.com/autowarefoundation/autoware_universe.git;${ROS_BRANCH};protocol=https"
SRCREV = "815d3f1b5c532eaccab33f0479819af8535919d2"
S = "${WORKDIR}/git/planning/autoware_trajectory_modifier"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
