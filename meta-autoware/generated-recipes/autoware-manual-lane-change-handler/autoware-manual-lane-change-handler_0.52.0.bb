# Generated by mash -- DO NOT EDIT. See PLAN.md §5/§6 and
# meta-autoware/classes/autoware-fixups.bbclass for fixes.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "Manual lane change handler node extracted from autoware_mission_planner_universe"
AUTHOR = "Arjun Jagdish Ram <arjun.ram@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "autoware_universe"
ROS_BPN = "autoware_manual_lane_change_handler"

ROS_BUILD_DEPENDS = "\
    autoware-internal-debug-msgs\
    autoware-lanelet2-extension\
    autoware-map-msgs\
    autoware-mission-planner-universe\
    autoware-planning-msgs\
    autoware-route-handler\
    nav-msgs\
    rclcpp\
    rclcpp-components\
    tier4-external-api-msgs\
    tier4-planning-msgs\
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native\
"

ROS_EXPORT_DEPENDS = "\
    autoware-internal-debug-msgs\
    autoware-lanelet2-extension\
    autoware-map-msgs\
    autoware-mission-planner-universe\
    autoware-planning-msgs\
    autoware-route-handler\
    nav-msgs\
    rclcpp\
    rclcpp-components\
    tier4-external-api-msgs\
    tier4-planning-msgs\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    autoware-internal-debug-msgs\
    autoware-lanelet2-extension\
    autoware-map-msgs\
    autoware-mission-planner-universe\
    autoware-planning-msgs\
    autoware-route-handler\
    nav-msgs\
    rclcpp\
    rclcpp-components\
    tier4-external-api-msgs\
    tier4-planning-msgs\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=humble"
SRC_URI = "git://github.com/autowarefoundation/autoware_universe.git;${ROS_BRANCH};protocol=https"
SRCREV = "6e477c645efec33f7909095eea684474e97f5e3d"
S = "${WORKDIR}/git/planning/autoware_manual_lane_change_handler"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
