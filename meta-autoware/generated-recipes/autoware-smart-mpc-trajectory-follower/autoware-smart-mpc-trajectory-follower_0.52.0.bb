# Generated by mash -- DO NOT EDIT. See PLAN.md §5/§6 and
# meta-autoware/classes/autoware-fixups.bbclass for fixes.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "Nodes to follow a trajectory by generating control commands using smart mpc"
AUTHOR = "Masayuki Aino <masayuki.aino@proxima-ai-tech.com>"
ROS_AUTHOR = "Masayuki Aino <masayuki.aino@proxima-ai-tech.com>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_universe"
ROS_BPN = "autoware_smart_mpc_trajectory_follower"

ROS_BUILD_DEPENDS = "\
    autoware-adapi-v1-msgs\
    autoware-control-msgs\
    autoware-motion-utils\
    autoware-planning-msgs\
    autoware-system-msgs\
    autoware-utils\
    autoware-vehicle-cmd-gate\
    autoware-vehicle-msgs\
    pybind11-vendor\
    python3-scipy\
    rclcpp\
    rclcpp-components\
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native\
    ament-cmake-python-native\
    autoware-cmake-native\
"

ROS_EXPORT_DEPENDS = "\
    autoware-adapi-v1-msgs\
    autoware-control-msgs\
    autoware-motion-utils\
    autoware-planning-msgs\
    autoware-system-msgs\
    autoware-utils\
    autoware-vehicle-cmd-gate\
    autoware-vehicle-msgs\
    pybind11-vendor\
    python3-scipy\
    rclcpp\
    rclcpp-components\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ros2launch\
    autoware-adapi-v1-msgs\
    autoware-control-msgs\
    autoware-motion-utils\
    autoware-planning-msgs\
    autoware-system-msgs\
    autoware-utils\
    autoware-vehicle-cmd-gate\
    autoware-vehicle-msgs\
    pybind11-vendor\
    python3-scipy\
    rclcpp\
    rclcpp-components\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-ros\
    ament-index-python\
    ament-lint-auto\
    autoware-lint-common\
    autoware-testing\
    ros-testing\
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=humble"
SRC_URI = "git://github.com/autowarefoundation/autoware_universe.git;${ROS_BRANCH};protocol=https"
SRCREV = "6e477c645efec33f7909095eea684474e97f5e3d"
S = "${WORKDIR}/git/control/autoware_smart_mpc_trajectory_follower"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
