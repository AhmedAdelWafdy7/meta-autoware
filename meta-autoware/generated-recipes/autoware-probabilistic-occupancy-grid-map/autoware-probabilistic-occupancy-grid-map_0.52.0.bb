# Generated by mash -- DO NOT EDIT. See PLAN.md §5/§6 and
# meta-autoware/classes/autoware-fixups.bbclass for fixes.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "generate probabilistic occupancy grid map"
AUTHOR = "Yukihiro Saito <yukihiro.saito@tier4.jp>"
ROS_AUTHOR = "Yukihiro Saito <yukihiro.saito@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_universe"
ROS_BPN = "autoware_probabilistic_occupancy_grid_map"

ROS_BUILD_DEPENDS = "\
    autoware-cuda-dependency-meta\
    autoware-cuda-utils\
    autoware-utils\
    grid-map-costmap-2d\
    grid-map-msgs\
    grid-map-ros\
    laser-geometry\
    message-filters\
    nav2-costmap-2d\
    nav-msgs\
    pcl-ros\
    rclcpp\
    rclcpp-components\
    sensor-msgs\
    tf2-eigen\
    tf2-ros\
    tf2-sensor-msgs\
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native\
    autoware-cmake-native\
    eigen3-cmake-module-native\
"

ROS_EXPORT_DEPENDS = "\
    autoware-cuda-dependency-meta\
    autoware-cuda-utils\
    autoware-utils\
    grid-map-costmap-2d\
    grid-map-msgs\
    grid-map-ros\
    laser-geometry\
    message-filters\
    nav2-costmap-2d\
    nav-msgs\
    pcl-ros\
    rclcpp\
    rclcpp-components\
    sensor-msgs\
    tf2-eigen\
    tf2-ros\
    tf2-sensor-msgs\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    autoware-pointcloud-preprocessor\
    pointcloud-to-laserscan\
    autoware-cuda-dependency-meta\
    autoware-cuda-utils\
    autoware-utils\
    grid-map-costmap-2d\
    grid-map-msgs\
    grid-map-ros\
    laser-geometry\
    message-filters\
    nav2-costmap-2d\
    nav-msgs\
    pcl-ros\
    rclcpp\
    rclcpp-components\
    sensor-msgs\
    tf2-eigen\
    tf2-ros\
    tf2-sensor-msgs\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest\
    ament-lint-auto\
    autoware-lint-common\
    autoware-pointcloud-preprocessor\
    launch\
    launch-ros\
    launch-testing\
    launch-testing-ament-cmake\
    launch-testing-ros\
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=humble"
SRC_URI = "git://github.com/autowarefoundation/autoware_universe.git;${ROS_BRANCH};protocol=https"
SRCREV = "6e477c645efec33f7909095eea684474e97f5e3d"
S = "${WORKDIR}/git/perception/autoware_probabilistic_occupancy_grid_map"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
