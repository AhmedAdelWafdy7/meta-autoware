# Generated by mash -- DO NOT EDIT. See PLAN.md §5/§6 and
# meta-autoware/classes/autoware-fixups.bbclass for fixes.

# Recipe created by mash
#
# Copyright (c) 2025 Open Source Robotics Foundation, Inc.

inherit ros_distro_jazzy
inherit mash_generated

DESCRIPTION = "The autoware_ekf_localizer package"
AUTHOR = "Takamasa Horibe <takamasa.horibe@tier4.jp>"
ROS_AUTHOR = "Takamasa Horibe <takamasa.horibe@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_core"
ROS_BPN = "autoware_ekf_localizer"

ROS_BUILD_DEPENDS = "\
    libeigen\
    autoware-agnocast-wrapper\
    autoware-internal-debug-msgs\
    autoware-kalman-filter\
    autoware-localization-util\
    autoware-utils-geometry\
    autoware-utils-logging\
    autoware-utils-system\
    diagnostic-msgs\
    fmt\
    geometry-msgs\
    nav-msgs\
    rclcpp\
    rclcpp-components\
    std-srvs\
    tf2\
    tf2-ros\
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native\
    autoware-cmake-native\
    eigen3-cmake-module-native\
"

ROS_EXPORT_DEPENDS = "\
    autoware-agnocast-wrapper\
    autoware-internal-debug-msgs\
    autoware-kalman-filter\
    autoware-localization-util\
    autoware-utils-geometry\
    autoware-utils-logging\
    autoware-utils-system\
    diagnostic-msgs\
    fmt\
    geometry-msgs\
    nav-msgs\
    rclcpp\
    rclcpp-components\
    std-srvs\
    tf2\
    tf2-ros\
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    autoware-agnocast-wrapper\
    autoware-internal-debug-msgs\
    autoware-kalman-filter\
    autoware-localization-util\
    autoware-utils-geometry\
    autoware-utils-logging\
    autoware-utils-system\
    diagnostic-msgs\
    fmt\
    geometry-msgs\
    nav-msgs\
    rclcpp\
    rclcpp-components\
    std-srvs\
    tf2\
    tf2-ros\
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-ros\
    ament-lint-auto\
    autoware-lint-common\
    launch-testing-ament-cmake\
    ros-testing\
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we
# needed them to build this package (even though we actually don't) so
# that they're guaranteed to have been staged should this package appear
# in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=humble"
SRC_URI = "git://github.com/autowarefoundation/autoware_core.git;${ROS_BRANCH};protocol=https"
SRCREV = "f25f83c632c1984ec276c894c41857d4abc0dad8"
S = "${WORKDIR}/git/localization/autoware_ekf_localizer"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
