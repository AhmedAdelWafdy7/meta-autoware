# Boost 1.87 removed ip::address::from_string() (wrynose)
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-udp_driver-build-with-Boost-1.87-and-later.patch"
