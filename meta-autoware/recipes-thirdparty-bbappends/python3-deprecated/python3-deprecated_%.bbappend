# acados_template imports it when generating solver code (acados-codegen.bbclass)
BBCLASSEXTEND = "native"
