# fmt 11 moved fmt::join to fmt/ranges.h (wrynose)
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-autoware_behavior_path_lane_change_module-include-fmt-ranges.h-for-fmt-join.patch"
