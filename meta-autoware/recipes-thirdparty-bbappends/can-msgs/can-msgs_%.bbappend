# package.xml says plain "BSD", but can_msgs ships no license text and the only one in
# ros_canopen is the LGPL-3.0 LICENSE at its root; use that until upstream says otherwise
LICENSE = "LGPL-3.0-only"
