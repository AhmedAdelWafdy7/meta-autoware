# Generates its acados MPC solver code at build time
inherit acados-codegen
