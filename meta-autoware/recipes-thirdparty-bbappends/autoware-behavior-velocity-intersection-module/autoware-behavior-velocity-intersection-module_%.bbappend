# Boost.Uuid 1.86 made boost::uuids::uuid a non-aggregate (wrynose)
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-autoware_behavior_velocity_intersection_module-initialise-the-uuid-for-Boost-1.86.patch"
